## boards/arm/holyiot_18010/Kconfig.holyiot_18010
```kconfig
# Copyright (c) 2024
# SPDX-License-Identifier: MIT

config BOARD_HOLYIOT_18010
	select SOC_NRF52840_QIAA
```
